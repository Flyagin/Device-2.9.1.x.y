<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v.9.01\device_2_v_9_1_9.ewp</path>
  </project>
  <batchBuild/>
</workspace>


